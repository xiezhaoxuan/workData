# Keil uVision project SysTick.uvproj, settings and files
target STM32L152-EVAL (ARM-ADS)
  device: STM32L152VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32L152-EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32L1XX_MD, USE_STM32L152_EVAL
  c include: ..\inc;..\..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32L1xx;..\..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\inc;..\..\..\..\Utilities\STM32_EVAL\STM32L152_EVAL;..\..\..\..\Libraries\CMSIS\Device\ST\STM32L1xx\Include;..\..\..\..\Utilities\STM32_EVAL\Common
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group User
    ../src/: main.c stm32l1xx_it.c
  group StdPeriph_Driver
    ../../../../LIBRARIES/STM32L1xx_StdPeriph_Driver/src/: stm32l1xx_rcc.c stm32l1xx_spi.c misc.c stm32l1xx_dma.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_usart.c stm32l1xx_exti.c stm32l1xx_syscfg.c
    ../../../../Libraries/STM32L1xx_StdPeriph_Driver/src/: stm32l1xx_sdio.c
  group CMSIS
    ../src/: system_stm32l1xx.c
  group STM32_EVAL
    ../../../../Utilities/STM32_EVAL/STM32L152_EVAL/: stm32l152_eval.c
    ../../../../Utilities/STM32_EVAL/STM32L152D_EVAL/: stm32l152d_eval.c
  group MDK-ARM
    ../../../../Libraries/CMSIS/Device/ST/STM32L1xx/Source/Templates/arm/: startup_stm32l1xx_md.s startup_stm32l1xx_hd.s
  group Doc
    ../: readme.txt
target STM32L152D-EVAL (ARM-ADS)
  device: STM32L152ZD STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x805FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32L152D-EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32L1XX_HD, USE_STM32L152D_EVAL
  c include: ..\inc;..\..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32L1xx;..\..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\inc;..\..\..\..\Utilities\STM32_EVAL\STM32L152D_EVAL;..\..\..\..\Libraries\CMSIS\Device\ST\STM32L1xx\Include;..\..\..\..\Utilities\STM32_EVAL\Common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0xc000
