# Keil uVision project ILI9341-16bit-tp_Uv2.uvproj, settings and files
target Target 1 (MCS-51)
  device: W78E516B Winbond
  cpu: IRAM(0 - 0xFF) XRAM(0- 0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: TP-9341-8BIT IVO280 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 tp-9325.C
